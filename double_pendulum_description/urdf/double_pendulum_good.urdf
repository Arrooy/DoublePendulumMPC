Commit message: OpenLoop Works. The model seems a bit off.

File: double_pendulum_description/urdf/double_pendulum_good.urdf (robot description, URDF)
Before this commit: robot 2dof_planar, 3 links, 2 joints
Links:
- link link1: mass 0.1 -> 0.2
- link link2: mass 0.14 -> 0.15
